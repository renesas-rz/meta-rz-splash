FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://renesas_logomark_l.png;outsuffix=default"
